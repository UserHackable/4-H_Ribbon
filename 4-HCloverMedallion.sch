File: 4-HCloverMedallion.sch (EAGLE design)
At the start: 25 parts, among them J1 ICSP, U1 TINY85-20-DIP

Commit message: updating files
Parts:
- U$2: value 4H-LOGO14 -> (none)
